# Keil uVision project keil_ds18b20_test.uvprojx, settings and files
target ROM (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ds18b20_test
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD
  c include: ../../apps/test_ds18b20;../../driver;../../cmsis/device/STM32F103C8;../../cmsis/core;../../cmsis/RTT/RTT;../../cmsis/RTT/Config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\bsp\Stm32F103C8_ROM.sct
  group Source Group 1
    ../../apps/test_ds18b20/: main.c
    ../../driver/: onewire.c ds18b20.c gpio.c systick.c debug.c
    ../../cmsis/device/STM32F103C8/: system_stm32f10x.c startup_stm32f10x_md.s
    ../../bsp/STM32F103C8/: bsp_irq.c
  group RTT
    ../../cmsis/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../cmsis/RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
target RAM (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: ds18b20_test
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, VECT_TAB_SRAM
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x2ffc
  memory RVCT9: RAM 0x20003000 size 0x1000
  scatter file: ..\..\bsp\Stm32F103C8_RAM.sct
